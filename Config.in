## Config.in
```kconfig
config BR2_PACKAGE_SUFOTA
	bool "SUFOTA"
	help
	  This package provides a custom C program for handling SUFOTA.
```
